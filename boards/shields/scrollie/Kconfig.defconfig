## boards/shields/scrollie/Kconfig.defconfig
```kconfig
if SHIELD_SCROLLIE

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Scrollie"

endif
```
